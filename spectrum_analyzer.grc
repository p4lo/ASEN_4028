options:
  parameters:
    generate_options: qt_gui
    id: spectrum_analyzer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_frequency
  id: variable_qtgui_range
  parameters:
    min_len: '21'
    orient: Qt.Horizontal
    start: 2350e6
    step: 10e6
    stop: 2500e6
    value: 2400e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 60e6
  states: {}
- name: tx_center_freq
  id: variable_qtgui_range
  parameters:
    label: Transmit Center Frequency
    orient: Qt.Horizontal
    start: 2350e6
    step: 10e6
    stop: 2500e6
    value: 2410e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: '0'
    channel_mode: '0'
    gain_dB_ch0: tx_gain
    oversample: '0'
    pa_path_ch0: '1'
    rf_freq: tx_center_freq
    samp_rate: samp_rate
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 60e6
    calibr_bandw_ch0: '0'
    ch_align: 'False'
    channel_mode: '0'
    gain_dB_ch0: rx_gain
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: center_frequency
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_frequency
    fftsize: '1024'
    name: Spectrum Analyzer
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}

connections:
- [analog_const_source_x_0, '0', limesdr_sink_0, '0']
- [limesdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
