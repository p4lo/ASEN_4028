options:
  parameters:
    generate_options: qt_gui
    id: spectrum_analyzer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_frequency
  id: variable_qtgui_range
  parameters:
    min_len: '21'
    orient: Qt.Horizontal
    start: 2650e6
    step: 5e6
    stop: 2750e6
    value: 2700e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    calibr_bandw_ch0: 5e6
    ch_align: 'False'
    channel_mode: '0'
    digital_bandw_ch0: 5e6
    gain_dB_ch0: rx_gain
    lna_path_ch0: '1'
    oversample: '0'
    rf_freq: center_frequency
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '30000'
    name: Spectrum Analyzer
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}

connections:
- [limesdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
