options:
  parameters:
    author: thomasian06
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: tone_tx
  states: {}

blocks:
- name: cent_freq
  id: variable_qtgui_range
  parameters:
    label: Transmit Center Frequency
    orient: Qt.Horizontal
    start: 2350e6
    step: 5e6
    stop: 2450e6
    value: 2400e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Transmit Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: tx_gain
    oversample: '0'
    pa_path_ch0: '1'
    rf_freq: cent_freq
    samp_rate: samp_rate
  states: {}

connections:
- [analog_const_source_x_0, '0', limesdr_sink_0, '0']

metadata:
  file_format: 1
