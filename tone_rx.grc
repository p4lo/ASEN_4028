options:
  parameters:
    author: thomasian06
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Tone Receive
  states: {}

blocks:
- name: cent_freq
  id: variable_qtgui_range
  parameters:
    label: Rx Center Frequency
    orient: Qt.Horizontal
    start: 2350e6
    step: 5e6
    stop: 2450e6
    value: 2400e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Receive Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    ch_align: 'False'
    channel_mode: '0'
    gain_dB_ch0: rx_gain
    oversample: '0'
    rf_freq: cent_freq
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [limesdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
