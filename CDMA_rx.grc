options:
  parameters:
    author: thomasian06
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: CDMA_rx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 12e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/thomasian06/Documents/Testing_Data/rx1_12m_LSB
    type: complex
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    calibr_bandw_ch0: 5e6
    ch_align: 'False'
    channel_mode: '0'
    gain_dB_ch0: '50'
    lna_path_ch0: '1'
    oversample: '0'
    rf_freq: 2.7e9
    samp_rate: samp_rate
  states: {}

connections:
- [limesdr_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
