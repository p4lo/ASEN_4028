options:
  parameters:
    author: thomasian06
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: CDMA1_tx
  states: {}

blocks:
- name: bpsk_mod
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.046e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/thomasian06/Documents/ASEN_4028/code1.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk_mod
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: '65'
    oversample: '0'
    pa_path_ch0: '1'
    rf_freq: 2.4e9
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', limesdr_sink_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
