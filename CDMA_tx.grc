options:
  parameters:
    author: thomasian06
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: CDMA1_tx
  states: {}

blocks:
- name: bpsk_mod
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.046e6
  states: {}
- name: tx_center_freq
  id: variable_qtgui_range
  parameters:
    label: Transmit Center Frequency
    orient: Qt.Horizontal
    start: 2650e6
    step: 5e6
    stop: 2750e6
    value: 2700e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Transmit Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '73'
    value: '73'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/thomasian06/Documents/ASEN_4028/code1.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk_mod
    differential: 'False'
    excess_bw: '100'
    samples_per_symbol: '2'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: tx_gain
    oversample: '0'
    pa_path_ch0: '1'
    rf_freq: tx_center_freq
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', limesdr_sink_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
